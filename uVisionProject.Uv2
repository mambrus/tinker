### uVision2 Project, (C) Keil Software
### Do not modify !

Target (XC167), 0x0002 // Tools: '166/167'

Group (Dave Files)
Group (TinKer)

File 1,1,<.\bsp\XC167_Keil\dave\MAIN.C><MAIN.C> 0x0 
File 1,1,<.\bsp\XC167_Keil\dave\ASC0.C><ASC0.C> 0x0 
File 1,1,<.\bsp\XC167_Keil\dave\ASC1.C><ASC1.C> 0x0 
File 1,1,<.\bsp\XC167_Keil\dave\GPT1.C><GPT1.C> 0x0 
File 1,1,<.\bsp\XC167_Keil\dave\GPT2.C><GPT2.C> 0x0 
File 1,1,<.\bsp\XC167_Keil\dave\IO.C><IO.C> 0x0 
File 2,1,<.\src\tk.c><tk.c> 0x0 
File 2,1,<.\src\time.c><time.c> 0x0 
File 2,1,<.\bsp\XC167_Keil\tk_hwsys_keilC166.c><tk_hwsys_keilC166.c> 0x0 
File 2,1,<.\src\tk_sysqueues.c><tk_sysqueues.c> 0x0 
File 2,1,<.\src\errno.c><errno.c> 0x0 
File 2,1,<.\src\mqueue.c><mqueue.c> 0x0 
File 2,1,<.\src\pthread_sched.c><pthread_sched.c> 0x0 
File 2,1,<.\src\pthread_sync.c><pthread_sync.c> 0x0 
File 2,1,<.\src\semaphore.c><semaphore.c> 0x0 
File 2,1,<.\src\tk_ansi_search.c><tk_ansi_search.c> 0x0 
File 2,1,<.\src\tk_itc.c><tk_itc.c> 0x0 
File 2,1,<.\src\tk_mem.c><tk_mem.c> 0x0 
File 2,1,<.\src\tk_ptime.c><tk_ptime.c> 0x0 
File 2,1,<.\src\tk_tick.c><tk_tick.c> 0x0 


Options 1,0,0  // Target 'XC167'
 Device (XC167CI)
 Vendor (Infineon)
 Cpu (IRAM(0xF600-0xFDFF) XRAM(0xC000-0xCFFF) IROM(0xC00000-0xC1FFFF) CLOCK(20000000) MOD167 MODV2)
 FlashUt ()
 StupF ("LIB\START_V2.A66" ("XC16x/Super10 Startup Code"))
 FlashDR ()
 Rgf (XC167.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg ()
 TgStat=0
 OutDir (.\tmp\XC167\)
 OutName (..\..\TinKer_XC167)
 GenApp=0
 GenLib=1
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\tmp\XC167\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 Model=6
 RTOS=0
 nHold=6
 iHold=65535
 sHold=65535
 bHold=65535
 MOD167=0
 MODV2=1
 UseOnChipRom=1
 UseOnchipXCAN=1
 UseOnchipXRAM2=0
 NearRam=0
 NearRom=0
 ExtMem 0 0,0,0
 ExtMem 1 0,4194304,524288
 ExtMem 2 0,0,0
 ExtMem 3 0,0,0
 ExtMem 4 0,0,0
 ExtMem 5 0,0,0
 Optimize=6
 SpeedSize=1
 RegColor=0
 Static=0
 WarningLev=2
 Alias=1
 Order=0
 UnsignedChar=0
 NoDppSave=0
 Float64=0
 SaveUsr=0
 Reorder=0
 cMisc (MODV2 DYNAMICUSRSTK REENTRANT SAVEUSR )
 Define (DEVICE=XC167,TK_COMP_ITC=1,TK_COMP_PTIMER=1,TK_COMP_KMEM=1,TK_COMP_PTHREAD=1,TK_COMP_POSIX_RT=1)
 Undefine ()
 INCC6 (include, ../)
 EC166 { 2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ECMISC ()
 ECDEFINE ()
 ECUNDEF ()
 ECINC ()
 MPL=1
 CASE=0
 aMisc (MODV2)
 aSet ()
 aReset ()
 INCA6 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 useLinkFile=0
 LnkFile ()
 LinkOnly=0
 UseTargSet=1
 DppUse=0
 nDataSel=2
 nConstSel=1
 NearDataStr ()
 NearConstStr ()
 CinitTab (0xC00000 - 0xC1FFFF)
 IntVectAddr ()
 lWarnLev=2
 lDisWarn ()
 lAssign ()
 lRegbank ()
 lReserve ()
 lMisc ()
 lClasses ()
 lSect ()
  OPTDL (S166.DLL)(-cMODV2)(D167.DLL)(-pX167CI)(S166.DLL)(-cMODV2)(T167.DLL)(-pX167CI)
  OPTDBG 44029,-1,()()()()()()()()()() (MONITOR\MON166.DLL)()()()
 FLASH1 { 1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 ()
 FLASH3 ("" ())
EndOpt

